# Keil uVision project SmartKitchenSystem.uvprojx, settings and files
target Target_1 (6220000::V6.22::ARMCLANG)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: SmartKitchenSystem
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: __FPU_PRESENT
  c include: C:\ti\TivaWare_C_Series-2.1.4.178;C:\ti\TivaWare_C_Series-2.1.4.178\inc
  asm include: C:\ti\TivaWare_C_Series-2.1.4.178\driverlib\rvmdk
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source Group 1
    ./: main.c adc.c adc.h led.c led.h switch.c switch.h uart.c uart.h tasks.c tasks.h
software components: CMSIS:CORE 6.2.0, RTOS:Config 11.3.0, RTOS:Core 11.3.0, RTOS:Heap 11.3.0, Device:Startup 1.0.1
